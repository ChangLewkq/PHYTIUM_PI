# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\Start;.\Library;.\User;.\System;.\Hardware;.\RT-Thread\include;.\RT-Thread\libcpu\arm\cortex-m3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h
  group System
    ./System/: Delay.c Delay.h Timer.c Timer.h
  group Hardware
    ./Hardware/: LED.c LED.h OLED.c OLED.h OLED_Data.c OLED_Data.h MPU6050.c MPU6050.h MPU6050_Reg.h MyI2C.c MyI2C.h Motor.c Motor.h PWM.c PWM.h Encoder.c Encoder.h BlueSerial.c BlueSerial.h iwdg.c ultrasonic.c config.h iwdg.h ultrasonic.h ChassisMap.c ChassisMap.h ChassisSpeed.c ChassisSpeed.h WheelPID.c WheelPID.h FlytProtocol.c FlytProtocol.h FlytSerial.c FlytSerial.h app_safety.c app_safety.h app_imu.c app_imu.h app_chassis.c app_chassis.h app_debug.c app_debug.h app_status.c app_status.h app_health.c app_health.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h board.c
  group RT-Thread
    ./RT-Thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
    ./RT-Thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ./RT-Thread/libcpu/arm/common/: div0.c
